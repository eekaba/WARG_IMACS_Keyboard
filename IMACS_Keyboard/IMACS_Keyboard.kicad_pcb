# Repository eekaba/WARG_IMACS_Keyboard

## KiCad design IMACS_Keyboard/IMACS_Keyboard.kicad_pcb

Board: 2 copper layers, 321.5 x 116.7 mm, 123 parts (62 on the bottom side), 82 nets.

Parts:
A1: Keyswitch; MX_PCB_1.00u
B1: Keyswitch; MX_PCB_1.00u
BKSLSH1: Keyswitch; MX_PCB_1.00u
BKSP1: Keyswitch; MX_PCB_1.00u
BRKT_C1: Keyswitch; MX_PCB_1.00u
BRKT_O1: Keyswitch; MX_PCB_1.00u
C1: Keyswitch; MX_PCB_1.00u
CAPS1: Keyswitch; MX_PCB_1.00u
COLON1: Keyswitch; MX_PCB_1.00u
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61: Diode; Diode_DO-35
D_KEY1: Keyswitch; MX_PCB_1.00u
E1: Keyswitch; MX_PCB_1.00u
ENTER1: Keyswitch; MX_PCB_1.00u
ESC1: Keyswitch; MX_PCB_1.00u
F1: Keyswitch; MX_PCB_1.00u
FN1: Keyswitch; MX_PCB_1.00u
G1: Keyswitch; MX_PCB_1.00u
H1: Keyswitch; MX_PCB_1.00u
I1: Keyswitch; MX_PCB_1.00u
J1: Keyswitch; MX_PCB_1.00u
K1: Keyswitch; MX_PCB_1.00u
L1: Keyswitch; MX_PCB_1.00u
L_ALT1: Keyswitch; MX_PCB_1.00u
L_CHEV1: Keyswitch; MX_PCB_1.00u
L_CTRL1: Keyswitch; MX_PCB_1.00u
L_SHIFT1: Keyswitch; MX_PCB_1.00u
M1: Keyswitch; MX_PCB_1.00u
MENU1: Keyswitch; MX_PCB_1.00u
MINUS1: Keyswitch; MX_PCB_1.00u
N1: Keyswitch; MX_PCB_1.00u
NUM1, NUM2, NUM3, NUM4, NUM5, NUM6, NUM7, NUM8, NUM9, NUM10: Keyswitch; MX_PCB_1.00u
O1: Keyswitch; MX_PCB_1.00u
P1: Keyswitch; MX_PCB_1.00u
PLUS1: Keyswitch; MX_PCB_1.00u
Q1: Keyswitch; MX_PCB_1.00u
QUOTE1: Keyswitch; MX_PCB_1.00u
R1: Keyswitch; MX_PCB_1.00u
R_ALT1: Keyswitch; MX_PCB_1.00u
R_CHEV1: Keyswitch; MX_PCB_1.00u
R_CTRL1: Keyswitch; MX_PCB_1.00u
R_SHIFT1: Keyswitch; MX_PCB_1.00u
S1: Keyswitch; MX_PCB_1.00u
SLSH1: Keyswitch; MX_PCB_1.00u
SPACE1: Keyswitch; MX_PCB_1.00u
T1: Keyswitch; MX_PCB_1.00u
TAB1: Keyswitch; MX_PCB_1.00u
U1: SC0915; MODULE_SC0915
U2: Keyswitch; MX_PCB_1.00u
V1: Keyswitch; MX_PCB_1.00u
W1: Keyswitch; MX_PCB_1.00u
WIN1: Keyswitch; MX_PCB_1.00u
X1: Keyswitch; MX_PCB_1.00u
Y1: Keyswitch; MX_PCB_1.00u
Z1: Keyswitch; MX_PCB_1.00u

Connections:
COL0: BKSLSH1.1, BKSP1.1, U1.7 (GP5)
COL1: BRKT_C1.1, ENTER1.1, PLUS1.1, R_CTRL1.1, U1.9 (GP6)
COL2: BRKT_O1.1, MENU1.1, MINUS1.1, QUOTE1.1, R_SHIFT1.1, U1.10 (GP7)
COL3: COLON1.1, FN1.1, NUM10.1, P1.1, SLSH1.1, U1.11 (GP8)
COL4: L1.1, NUM9.1, O1.1, R_ALT1.1, R_CHEV1.1, U1.12 (GP9)
COL5: I1.1, K1.1, L_CHEV1.1, NUM8.1, U1.14 (GP10)
COL6: J1.1, M1.1, NUM7.1, U1.15 (GP11), U2.1
COL7: H1.1, N1.1, NUM6.1, U1.16 (GP12), Y1.1
COL8: B1.1, G1.1, NUM5.1, SPACE1.1, T1.1, U1.17 (GP13)
COL9: F1.1, NUM4.1, R1.1, U1.19 (GP14), V1.1
COL10: C1.1, D_KEY1.1, E1.1, NUM3.1, U1.20 (GP15)
COL11: L_ALT1.1, NUM2.1, S1.1, U1.21 (GP16), W1.1, X1.1
COL12: A1.1, NUM1.1, Q1.1, U1.22 (GP17), WIN1.1, Z1.1
COL13: CAPS1.1, ESC1.1, L_CTRL1.1, L_SHIFT1.1, TAB1.1, U1.24 (GP18)
GND: U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.38 (GND), U1.D2 (GND)
unnamed: D1.2 (A), ESC1.2
unnamed: D2.2 (A), TAB1.2
unnamed: CAPS1.2, D3.2 (A)
unnamed: D4.2 (A), L_SHIFT1.2
unnamed: D5.2 (A), L_CTRL1.2
unnamed: D6.2 (A), NUM1.2
unnamed: D7.2 (A), Q1.2
unnamed: A1.2, D8.2 (A)
unnamed: D9.2 (A), Z1.2
unnamed: D10.2 (A), WIN1.2
unnamed: D11.2 (A), NUM2.2
unnamed: D12.2 (A), W1.2
unnamed: D13.2 (A), S1.2
unnamed: D14.2 (A), X1.2
unnamed: D15.2 (A), L_ALT1.2
unnamed: D16.2 (A), NUM3.2
unnamed: D17.2 (A), E1.2
unnamed: D18.2 (A), D_KEY1.2
unnamed: C1.2, D19.2 (A)
unnamed: D20.2 (A), NUM4.2
unnamed: D21.2 (A), R1.2
unnamed: D22.2 (A), F1.2
unnamed: D23.2 (A), V1.2
unnamed: D24.2 (A), NUM5.2
unnamed: D25.2 (A), T1.2
unnamed: D26.2 (A), G1.2
unnamed: B1.2, D27.2 (A)
unnamed: D28.2 (A), SPACE1.2
unnamed: D29.2 (A), NUM6.2
unnamed: D30.2 (A), Y1.2
unnamed: D31.2 (A), H1.2
unnamed: D32.2 (A), N1.2
unnamed: D33.2 (A), NUM7.2
unnamed: D34.2 (A), U2.2
unnamed: D35.2 (A), J1.2
unnamed: D36.2 (A), M1.2
unnamed: D37.2 (A), NUM8.2
unnamed: D38.2 (A), I1.2
unnamed: D39.2 (A), K1.2
unnamed: D40.2 (A), L_CHEV1.2
unnamed: D41.2 (A), NUM9.2
unnamed: D42.2 (A), O1.2
unnamed: D43.2 (A), L1.2
unnamed: D44.2 (A), R_CHEV1.2
unnamed: D45.2 (A), R_ALT1.2
unnamed: D46.2 (A), NUM10.2
unnamed: D47.2 (A), P1.2
unnamed: COLON1.2, D48.2 (A)
unnamed: D49.2 (A), SLSH1.2
unnamed: D50.2 (A), FN1.2
unnamed: D51.2 (A), MINUS1.2
unnamed: BRKT_O1.2, D52.2 (A)
unnamed: D53.2 (A), QUOTE1.2
unnamed: D54.2 (A), R_SHIFT1.2
unnamed: D55.2 (A), MENU1.2
unnamed: D56.2 (A), PLUS1.2
unnamed: BRKT_C1.2, D57.2 (A)
unnamed: D58.2 (A), ENTER1.2
unnamed: D59.2 (A), R_CTRL1.2
unnamed: BKSP1.2, D60.2 (A)
unnamed: BKSLSH1.2, D61.2 (A)
unnamed: U1.A (USB_SHIELD), U1.B (USB_SHIELD), U1.C (USB_SHIELD), U1.D (USB_SHIELD)
ROW0: D1.1 (K), D6.1 (K), D11.1 (K), D16.1 (K), D20.1 (K), D24.1 (K), D29.1 (K), D33.1 (K), D37.1 (K), D41.1 (K), D46.1 (K), D51.1 (K), D56.1 (K), D60.1 (K), U1.1 (GP0)
ROW1: D2.1 (K), D7.1 (K), D12.1 (K), D17.1 (K), D21.1 (K), D25.1 (K), D30.1 (K), D34.1 (K), D38.1 (K), D42.1 (K), D47.1 (K), D52.1 (K), D57.1 (K), D61.1 (K), U1.2 (GP1)
ROW2: D3.1 (K), D8.1 (K), D13.1 (K), D18.1 (K), D22.1 (K), D26.1 (K), D31.1 (K), D35.1 (K), D39.1 (K), D43.1 (K), D48.1 (K), D53.1 (K), D58.1 (K), U1.4 (GP2)
ROW3: D4.1 (K), D9.1 (K), D14.1 (K), D19.1 (K), D23.1 (K), D27.1 (K), D32.1 (K), D36.1 (K), D40.1 (K), D44.1 (K), D49.1 (K), D54.1 (K), U1.5 (GP3)
ROW4: D5.1 (K), D10.1 (K), D15.1 (K), D28.1 (K), D45.1 (K), D50.1 (K), D55.1 (K), D59.1 (K), U1.6 (GP4)

## Commit log

2024-08-10 Added Joe Scotto's KiCad library
2024-08-11 Completed Initial Revision
2024-08-11 Added mounting holes
2024-08-11 changed hole position
